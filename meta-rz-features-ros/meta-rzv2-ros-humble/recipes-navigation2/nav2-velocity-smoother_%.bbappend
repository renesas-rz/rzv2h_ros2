CXXFLAGS += "-Wno-deprecated-declarations"
