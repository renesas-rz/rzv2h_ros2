FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

EXCLUDE_FROM_SYSROOT = "usr/include/KHR/khrplatform.h"
